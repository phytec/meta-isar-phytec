inherit ubi-img ubifs-img
addtask do_ubi_image after do_ubifs_image
